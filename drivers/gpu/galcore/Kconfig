## drivers/gpu/galcore/Kconfig
```kconfig
menu "Vivante GPU support"

config VIVANTE_GALCORE
	tristate "Vivante GPU support"
	---help---
         Say Y to get the GPU driver support.

endmenu
```
